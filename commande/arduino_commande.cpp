

#include "arduino_commande.h"
#include<iostream>
#include <QDebug>
#include <QtSerialPort>
using namespace std;
arduino_commande::arduino_commande()
{
    serial = new QSerialPort();

}
arduino_commande::~arduino_commande()
{
    if (serial->isOpen())
        serial->close();
    delete serial;
}
int arduino_commande::connect_arduino()
{
    foreach(const QSerialPortInfo &serial_port_info,QSerialPortInfo::availablePorts())
    {
        if(serial_port_info.hasVendorIdentifier() && serial_port_info.hasProductIdentifier())
        {
            if(serial_port_info.vendorIdentifier()==arduino_uno_vendor_id && serial_port_info.productIdentifier()==arduino_uno_producy_id)
            {
                arduino_is_available=true;
                arduino_port_name=serial_port_info.portName();
            }
        }
    }
    qDebug() << "arduino_port_name is :" << arduino_port_name;
    if(arduino_is_available)
    {
        serial->setPortName(arduino_port_name);
        if(serial->open(QSerialPort::ReadWrite))
        {
            serial->setBaudRate(QSerialPort::Baud9600);
            serial->setDataBits(QSerialPort::Data8);
            serial->setParity(QSerialPort::NoParity);
            serial->setStopBits(QSerialPort::OneStop);
            serial->setFlowControl(QSerialPort::NoFlowControl);
            return 0;
        }
    }
    return 1;

}
int arduino_commande::close_arduino()
{
    if(serial->isOpen())
    {serial->close();
        return 0;
    }
    return 1;
}
QByteArray arduino_commande::read_from_arduino()
{
    if(serial->isReadable())
    {
        data=serial->readAll();
        return data;
    }
    else
    {
        qDebug() << "No data available";
        return QByteArray();  // Ou une autre valeur par défaut
    }
}
int arduino_commande::write_to_arduino(QByteArray d)
{
    if(serial->isWritable())
    {
        serial->write(d);
        return 0;
    }
    else
    {
        qDebug() << "Je ne peux pas écrire sur le port série";
        return 1;  // Ou une autre valeur pour indiquer l'échec
    }
}

